# Keil uVision project FlightController.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FlightController
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./: main.c InitSettings.c PWM.c ADC.c UART.c I2C.c Timers.c
  group Headers
    ./: PWM.h InitSettings.h ADC.h UART.h I2C.h Timers.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 2.2.3
